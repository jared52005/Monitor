# Keil uVision project APP_STM32F4xx.uvproj, settings and files
target BOARD_STM32F417_A (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: bin +hex
  c flags: Optim=1 oTime=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000, DEBUG_TRACE, OLIMEXP405_Cv10
  c include: ..\;..\..\LLD_STM32F4xx\CMSIS\Include;..\..\LLD_STM32F4xx\CMSIS\STM32F4xx\Include;..\..\LLD_STM32F4xx\STM32F4xx_StdPeriph_Driver\inc;..\..\LLD_STM32F4xx\usb_core;..\..\LLD_STM32F4xx\usb_ftdi_device;..\..\LLD_Inc_Shared;..\..\RTOS\include;..\..\RTOS\portable\RVDS\ARM_CM4F;..\..\BSW;..\..\LLD_STM32F4xx\usb_cdc_device
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group 0_STM32F4xx
    ../: startup_stm32f4xx.s
    ../../LLD_STM32F4xx/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../../LLD_STM32F4xx/: CanIf.c GpioIf.c SystemIf.c UartIf.c GptIf.c
  group 1_Drivers_USB_CDC
    ../../LLD_STM32F4xx/usb_cdc_device/: stm32f4_usb_vcp.c usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_cdc_core.c usbd_cdc_vcp.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c
  group 2_FreeRTOS
    ../../RTOS/: croutine.c event_groups.c list.c queue.c rtos_utils.c stream_buffer.c tasks.c timers.c
    ../: FreeRTOSConfig.h
    ../../RTOS/portable/MemMang/: heap_2.c
    ../../RTOS/portable/RVDS/ARM_CM4F/: port.c
  group 2_BSW
    ../../BSW/: led.c application.c CanRawLoopback.c
  group 3_APP_cantact_STM32F4xx
    ../: stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_conf.h main.c
